# Keil uVision project S800_NetworkClock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S800_NetworkClock_JIANGSJ +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: .\inc;.\driverlib
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./src/: main.c
  group Driverlib
    ./driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
